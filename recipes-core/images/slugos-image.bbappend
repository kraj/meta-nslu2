inherit nslu2-image
